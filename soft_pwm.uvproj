# Keil uVision project soft_pwm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 51-1st +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c arch.c driver.c f_idle.c f_poweron.c IAP.c moto.c uart.c
  group Document
    ./: readme.txt
